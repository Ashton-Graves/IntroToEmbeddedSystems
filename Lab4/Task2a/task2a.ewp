# IAR project task2a.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cstartup_M.c lab4t2a.h lcd.c lcd.h led.c led.h main2a.c SSD2119_Display2a.c SSD2119_Display2a.h SSD2119_Touch2a.c SSD2119_Touch2a.h switch.c switch.h TickFct_TrafficLight.c TickFct_TrafficLight.h timer_t2a.c timer_t2a.h tm4c1294ncpdt2a.h
    ../: PLL_Header.h PLL_Init.c PLL_Init.h
